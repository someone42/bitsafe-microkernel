# IAR project microkernel.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; NO_PROCESSES
  ICCARM.CCIncludePath2: ..\lib\CMSIS\Include; ..\lib\CMSIS\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NO_PROCESSES
  ILINK.IlinkOutputFile: microkernel.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: examples.c main.c process_table.h process_table_num.h process_table_types.h startup_stm32f4xx.s stm32f4xx_conf.h syscall.h system_stm32f4xx.c
  group CMSIS
    ../lib/CMSIS/Include/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../lib/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group Kernel
    ../kernel/: check_access.h check_access_asm.s crit_sect.c event.c interrupts.c kernel.h process.c queue.c scheduler.c scheduler_asm.s semaphore.c syscall_handler.c
  group STM32Peripheral
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
    ../lib/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_tim.h
  group Userspace library
    ../userspace/: svc.s userspace_lib.c userspace_lib.h
